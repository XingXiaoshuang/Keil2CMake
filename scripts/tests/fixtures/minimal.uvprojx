# Keil uVision project minimal.uvprojx, settings and files
target Board Debug ()
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firmware +hex
  c define: STM32F407xx;BOARD_REV=2
  c misc: --c99 --split_sections
  c include: .\Inc;$(EXTERNAL_INCLUDE)
  asm define: ASM_TEST
  asm misc: --xref
  asm include: .\AsmInc
  scatter file: .\fixed.sct
  link misc: --strict --callgraph
  group Application
    ./src/: main.c excluded.c
  group Generated
    $(BUILD_GEN)/: generated.c
